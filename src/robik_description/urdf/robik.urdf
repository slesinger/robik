Commit message: big reshuffle

File: src/robik_description/urdf/robik.urdf (robot description, URDF)
Before this commit: robot robik, 15 links, 14 joints
Links:
- link base_link: geometry collision box size=0.006 0.125 0.125; collision box size=0.006 0.22 0.15
